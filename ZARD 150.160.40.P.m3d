# KOMPAS-3D part (ZARD 150.160.40.P.m3d)

Model tree:
1. Булева операция:5
2. Булева операция:6
